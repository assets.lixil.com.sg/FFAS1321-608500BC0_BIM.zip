Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-29T16:45:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190731_1515(x64) - Exporter 20.1.1.1 - Alternate UI 20.1.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 29 16:45:55 2023 * Host: CHATPONG-DEE * Database: C:\Users\CHATPONG\AppData\Local\Temp\bd27b120-204b-4601-9960-67f846687d71\5b7b3013-c5b2-4d37-b835-2df08e3e1d6e\ifc * Database version: 5507 * Database creation date: Wed Mar 29 16:45:55 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 29 16:45:55 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 29 16:45:55 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (4)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: FFAS1321-608500BC0_REVIT:Acacia E Concealed BnS Main Mixing Valve, FFAS1321-608500BC0_REVIT:Acacia E Concealed BnS Main Mixing Valve:346404
In: Level 1
Material: Chrome Plated
Pset_DistributionFlowElementCommon - Reference: Acacia E Concealed BnS Main Mixing Valve; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Pset_ProductRequirements - Category: Plumbing Fixtures
